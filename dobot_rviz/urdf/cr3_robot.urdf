Commit message: cr3_urdf

File: dobot_rviz/urdf/cr3_robot.urdf (robot description, URDF)
Before this commit: robot cr3_robot, 8 links, 7 joints
Joints:
- joint joint4: type continuous -> revolute
- joint joint5: type continuous -> revolute
